## sdkconfig.defaults.esp32c6
```kconfig
CONFIG_PARTITION_TABLE_SINGLE_APP_LARGE=y
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
CONFIG_ASYNC_TCP_RUN_CORE0=y
CONFIG_ASYNC_TCP_RUNNING_CORE=0
```
